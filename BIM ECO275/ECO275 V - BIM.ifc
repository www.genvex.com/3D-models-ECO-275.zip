Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2020-09-21T09:53:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.11200.0000 - Exporter 18.0.0.412 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 21 09:53:47 2020 * Host: NINB1532 * Database: C:\Users\3113thmo\AppData\Local\Temp\{B9174A40-5B5E-4D33-B656-24333C15E5F5}\ifc * Database version: 5507 * Database creation date: Mon Sep 21 09:53:45 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 21 09:53:45 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 21 09:53:45 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Standard, Family1:Standard:201864
In: Level 1
Type - Material: Plate, 255_255_255, Steel - Polished, Snow, Smooth - Black, Light Red, Dark Green, Glossy - Black, 86_173_113, Default
Type - Dimensions - Connector_1_Diameter: 0 mm; Connector_2_Diameter: 0 mm; Connector_3_Diameter: 0 mm; Connector_4_Diameter: 0 mm; Connector_5_Diameter: 0 mm
Type - Identity Data - Description: Ventilation; Manufacturer: Genvex; Model: ECO275 V; Type Name: Standard; URL: www.genvex.com
Type - Other - Category: Generic Models; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_ManufacturerTypeInformation - Manufacturer: Genvex
Constraints - Offset: 0 mm
Dimensions - Area: 1.5867 m2; Volume: 0.330656 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction
